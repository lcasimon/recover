v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/Amplifier_PushPull.sym} 10 -20 0 0 {name=x1}
